## arch/x86/Kconfig
```kconfig
config X86
    bool
    default y

config 64BIT
    bool
    default y if X86

rsource "boot/Kconfig"
```
